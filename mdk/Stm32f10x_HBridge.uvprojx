# Keil uVision project Stm32f10x_HBridge.uvprojx, settings and files
target stm32f10x_HBridge (ARM-ADS)
  device: STM32F100RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Stm32f10x_HBridge +hex
  c flags: Optim=1
  c define: STM32F10X_MD_VL, USE_STDPERIPH_DRIVER
  c include: ..\..\CMSIS_STD_PERIPH_LIB\CMSIS\CM3\CoreSupport;..\..\CMSIS_STD_PERIPH_LIB\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\CMSIS_STD_PERIPH_LIB\STM32F10x_StdPeriph_Driver\inc;..\src
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group startup
    ./: startup_stm32f10x_md_vl.s
  group src
    ../src/: main.c stm32f10x_it.c user.c
  group CMSIS
    ../../CMSIS_STD_PERIPH_LIB/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../CMSIS_STD_PERIPH_LIB/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group Std_Periph_Lib
    ../../CMSIS_STD_PERIPH_LIB/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
